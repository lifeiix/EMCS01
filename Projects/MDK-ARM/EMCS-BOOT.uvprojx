# Keil uVision project EMCS-BOOT.uvprojx, settings and files
target STM32F30x-Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302RB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EMCS-BOOT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F30X,FW_TYPE=0x55
  c include: ..\..\Components\Drivers\CMSIS\Include;..\..\Components\Drivers\CMSIS\Device\ST\STM32F30x\Include;..\..\Components\Drivers\STM32F30x_StdPeriph_Driver\inc;..\..\Bootloader;..\..\Components\Platform\STM32F30x_MX01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Drivers/CMSIS/Device
    ../../Bootloader/: system_stm32f10x.c system_stm32f30x.c
    ../../Components/Drivers/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
    ../../Components/Drivers/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group Drivers/STM32F10x_StdPeriph_Driver
    ../../Components/Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers/STM32F30x_StdPeriph_Driver
    ../../Components/Drivers/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group Platform
    ../../Components/Platform/STM32F10x_WBFD/: stm32f10x_wbfd.c
    ../../Components/Platform/STM32F30x_MX01/: stm32f30x_mx01.c
  group User
    ../../Bootloader/: main.c stm32f10x_it.c stm32f30x_it.c aes.c can_bootloader.c
target STM32F10x-Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EMCS-BOOT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,FW_TYPE=0x55
  c include: ..\..\Components\Drivers\CMSIS\Include;..\..\Components\Drivers\CMSIS\Device\ST\STM32F10x\Include;..\..\Components\Drivers\STM32F10x_StdPeriph_Driver\inc;..\..\Bootloader;..\..\Components\Platform\STM32F10x_WBFD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
